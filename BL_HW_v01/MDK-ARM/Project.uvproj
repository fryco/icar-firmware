# Keil uVision project Project.uvproj, settings and files
target BL4HW_v01 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bl4hw_v01 +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\;..\src_comm\Libraries\CMSIS\CM3\CoreSupport;..\src_comm\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src_comm\Libraries\STM32F10x_StdPeriph_Driver\inc;..\src_comm\App;..\src_cust\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User_comm
    ../src_comm/App/: drv_flash.c main.c system_stm32f10x.c startup.s
  group User_cust
    ../src_cust/App/: drv_gpio.c
  group StdPeriph_Driver
    ../src_comm/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c misc.c stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
  group CMSIS
    ../src_comm/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
