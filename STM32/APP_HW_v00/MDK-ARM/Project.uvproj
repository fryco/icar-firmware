# Keil uVision project Project.uvproj, settings and files
target iCar4HW_v00 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: iCar4HW_v00 +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\;..\src_comm\Libraries\CMSIS\CM3\CoreSupport;..\src_comm\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src_comm\Libraries\STM32F10x_StdPeriph_Driver\inc;..\src_comm\App;..\src_cust\App;..\src_comm\ucos-II;..\src_comm\port;..\src_comm\uC-CPU;..\src_comm\uC-LIB;..\src_comm\uC-Probe
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\iCar.sct
  group User_comm
    ../src_comm/App/: main.c stm32f10x_it.c system_stm32f10x.c startup.s app_cfg.h app_gsm.c drv_uart.c drv_adc.c drv_rtc.c drv_iwdg.c drv_mg323.c app_taskmanager.c drv_flash.c app_obd.c drv_can.c
  group User_cust
    ../src_cust/App/: drv_gpio.c
  group StdPeriph_Driver
    ../src_comm/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
  group CMSIS
    ../src_comm/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Doc
    ./: readme.txt
  group ucos-II
    ../src_comm/ucos-II/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group port
    ../src_comm/port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uc-cpu
    ../src_comm/uC-CPU/: cpu_c.c cpu_a.asm
  group uc-lib
    ../src_comm/uC-LIB/: lib_mem.c lib_str.c lib_mem_a.asm
