# Keil uVision project Project.uvproj, settings and files
target BL_v01 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Bootloader +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\;..\source\Libraries\CMSIS\CM3\CoreSupport;..\source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\source\App;..\source\ucos-II;..\source\port;..\source\uC-CPU;..\source\uC-LIB;..\source\uC-Probe
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../source/App/: main.c system_stm32f10x.c startup.s drv_gpio.c drv_flash.c
  group StdPeriph_Driver
    ../source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c
  group CMSIS
    ../source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
