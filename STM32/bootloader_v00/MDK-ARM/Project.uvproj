# Keil uVision project Project.uvproj, settings and files
target BL_v00 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Bootloader +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\;..\source\Libraries\CMSIS\CM3\CoreSupport;..\source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\source\App;..\source\ucos-II;..\source\port;..\source\uC-CPU;..\source\uC-LIB;..\source\uC-Probe
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\iCar.sct
  group User
    ../source/App/: main.c stm32f10x_it.c system_stm32f10x.c startup.s drv_gpio.c drv_uart.c drv_rtc.c drv_iwdg.c drv_flash.c
  group StdPeriph_Driver
    ../source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
