# Keil uVision project Project.uvproj, settings and files
target iCar_OS (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: iCar +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\;..\source\Libraries\CMSIS\CM3\CoreSupport;..\source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\source\App;..\source\ucos-II;..\source\port;..\source\uC-CPU;..\source\uC-LIB;..\source\uC-Probe
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\iCar.sct
  group User
    ../source/App/: main.c stm32f10x_it.c system_stm32f10x.c startup.s app_cfg.h app_gsm.c drv_gpio.c drv_uart.c drv_adc.c drv_rtc.c drv_iwdg.c drv_mg323.c app_taskmanager.c drv_flash.c
  group StdPeriph_Driver
    ../source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Doc
    ./: readme.txt
  group ucos-II
    ../source/ucos-II/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group port
    ../source/port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uc-cpu
    ../source/uC-CPU/: cpu_c.c cpu_a.asm
  group uc-lib
    ../source/uC-LIB/: lib_mem.c lib_str.c lib_mem_a.asm
